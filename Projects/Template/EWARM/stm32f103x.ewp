# IAR project stm32f103x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; MINI_STM32
  ICCARM.CCIncludePath2: ..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\Include; ..\user; ..\delay; ..\led; ..\usart; ..\timer; ..\rich_led
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f103x.srec
  ILINK.IlinkOutputFile: stm32f103x.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration led_test (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103R8 ST STM32F103R8
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  group doc
    ../: readme.md
  group drivers
    ../delay/: delay.c
    ../led/: led.c
    ../timer/: timer.c
    ../usart/: usart.c
  group rich_led
    ../rich_led/: conf_led.c rich_led.c
  group stm32f10x/CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
    ../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group stm32f10x/STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../user/: main.c main_led.c stm32f10x_it.c
